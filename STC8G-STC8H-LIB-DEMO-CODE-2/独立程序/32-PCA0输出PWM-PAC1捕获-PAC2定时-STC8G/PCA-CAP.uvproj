# Keil uVision project PCA-CAP.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: PCA-CAP +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_PCA.c STC8G_PCA_Isr.c STC8G_H_NVIC.c
