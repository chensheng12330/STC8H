# Keil uVision project sleep.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: sleep +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c STC8G_H_Delay.c STC8G_H_Exti.c STC8G_H_Exti_Isr.c STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_UART.c STC8G_H_UART_Isr.c
