# Keil uVision project init.uvproj, settings and files
target init (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: init +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: init.c 功能说明.txt
