# Keil uVision project Mini DSO.uvproj, settings and files
target Mini_DSO (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Mini DSO +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group main
    ./: main.c delay.c settings.c ssd1306.c eeprom.c chart.c global.c adc_stc.c stc_usb_cdc_8h_xdata.LIB
