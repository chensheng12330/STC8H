# Keil uVision project UART3.uvproj, settings and files
target UART3 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: UART3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: UART3.c isr.asm 功能说明.txt
