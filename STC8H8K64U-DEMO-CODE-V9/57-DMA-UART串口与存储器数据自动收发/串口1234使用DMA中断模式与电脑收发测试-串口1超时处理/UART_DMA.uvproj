# Keil uVision project UART_DMA.uvproj, settings and files
target UART_DMA (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: UART_DMA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: isr.asm UART_DMA.c 功能说明.txt
