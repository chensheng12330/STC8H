# Keil uVision project ExternalRAM.uvproj, settings and files
target ExternalRAM (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: ExternalRAM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: ExternalRAM.c 功能说明.txt
