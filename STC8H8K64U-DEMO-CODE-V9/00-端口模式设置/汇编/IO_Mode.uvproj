# Keil uVision project IO_Mode.uvproj, settings and files
target IO_Mode (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: IO_Mode +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: IO_Mode.asm 功能说明.txt
