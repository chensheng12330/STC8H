# Keil uVision project sample.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H2K64T Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: sample +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: sample.c STC8_MDU16_V1.0.LIB 功能说明.txt
