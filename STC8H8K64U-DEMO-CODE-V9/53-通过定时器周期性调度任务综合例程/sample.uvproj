# Keil uVision project sample.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: sample +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Sources\inc
  group usr
    ./Sources/src/: main.c Task.c System_init.c
    ./: 功能说明.txt
  group isr
    ./Sources/isr/: STC8H_Timer_Isr.c
  group app
    ./Sources/src/: adc.c app.c app_adcKey.c app_display.c app_MatrixKey.c app_ntc.c app_rtc.c
