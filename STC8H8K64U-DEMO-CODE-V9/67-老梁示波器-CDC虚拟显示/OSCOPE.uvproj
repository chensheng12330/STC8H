# Keil uVision project OSCOPE.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: OSCOPE +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: inc;usb;.\inc;.\usb
  group Source Group 1
    ./: EEPROM.c uart.c OSCOPE-V2-8bit-CDC.c
  group USB
    ./usb/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
