# Keil uVision project D-LED.uvproj, settings and files
target D-LED (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: D-LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: D-LED.asm 功能说明.txt
