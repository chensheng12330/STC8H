# Keil uVision project I2C_Slave_INT.uvproj, settings and files
target I2C_Slave_INT (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: I2C_Slave_INT +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: I2C_Slave_INT.asm 功能说明.txt
