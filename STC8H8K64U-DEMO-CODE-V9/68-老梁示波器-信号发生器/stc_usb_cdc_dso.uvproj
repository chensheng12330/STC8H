# Keil uVision project stc_usb_cdc_dso.uvproj, settings and files
target dso (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc_usb_cdc_dso +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./src/: main.c
