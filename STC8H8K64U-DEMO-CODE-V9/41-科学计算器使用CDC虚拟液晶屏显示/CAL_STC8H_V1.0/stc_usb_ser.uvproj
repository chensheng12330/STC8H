# Keil uVision project stc_usb_ser.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc_usb_ser +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\middle;.\src;.\user;.\ware
  link misc: REMOVEUNUSED
  group Source Group 1
    ./src/: main.c
    ../COMM/: stc_usb_cdc_8h_xdata.LIB
  group hardware
    ./ware/: eeprom.c key.c oled.c tim.c spi.c
  group middle
    ./middle/: middle.c
  group uesr
    ./user/: calculus.c fun.c funcpic.c keyboard.c matrix.c nor_cal.c sensus.c solve.c menu.c
