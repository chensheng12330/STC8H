# Keil uVision project wake_up.uvproj, settings and files
target wake_up (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: wake_up +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: wake_up.asm 功能说明.txt
