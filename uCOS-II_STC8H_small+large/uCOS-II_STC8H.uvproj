# Keil uVision project uCOS-II_STC8H.uvproj, settings and files
target STC8H_TEST (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: uCOSII_STC8H +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\uCOS-II\Source;.\uCOS-II\Ports;.\uCOS-II\Cfg;.\Library
  link misc: REMOVEUNUSED
  group uC/OS-II
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./uCOS-II/Ports/: pendSV_ISR.A51 os_cpu.c os_cpu_a.c os_cpu.h
    ./uCOS-II/Cfg/: app_hooks.c os_cfg.h app_cfg.h
    ./Library/: config.h
  group Library
    ./: STARTUP.A51
  group mDrive
    ./: UART.C
  group Task
    ./: main.c Visualization.c task.c
  group 使用说明
    ./: 使用说明.txt
